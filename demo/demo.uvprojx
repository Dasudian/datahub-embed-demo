# Keil uVision project demo.uvprojx, settings and files
target Tem (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pro_template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,LWIP_DHCP
  c include: ..\include;..\include\inc;.\UCOSII\CONFIG;.\UCOSII\CORE;.\UCOSII\PORT;.\STM32F4xx_StdPeriph_Driver\inc;.\USER;.\CORE;.\LWIP;.\LWIP\lwip-1.4.1\src\include;.\LWIP\arch;.\LWIP_APP;.\LWIP\lwip-1.4.1\src\include\ipv4;.\MALLOC;.\SYSTEM\sys;.\STM32F4x7_ETH_Driver\inc;.\SYSTEM\usart;.\SYSTEM\delay;.\STM32_CONF
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group DATAHUB_LIB
    ../lib/: dasudian-datahub-sdk-3.0.0-STM32F4.lib
  group DATAHUB_API
    ../include/: DataHubClient.h DatahubNetwork.h DatahubTimer.h
  group USER
    ./USER/: DatahubNetwork.c main.c datahub_demo.c datahub_demo.h DatahubTimer.c
  group UCOSII_CONF
    ./UCOSII/CONFIG/: os_cfg.h includes.h
  group UCOSII_CORE
    ./UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group UCOSII_PORT
    ./UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group STM32_STD_DRIVER
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_fsmc.c
    ./STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_fsmc.h
  group CORE
    ./CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s core_cmFunc.h core_cmInstr.h
  group LWIP_API
    ./LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_ARCH
    ./LWIP/arch/: sys_arch.c
  group LWIP_CORE
    ./LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ./LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_APP
    ./LWIP_APP/: lwipopts.h lwip_comm.c lwip_comm.h lan8720.c lan8720.h
  group MALLOC
    ./MALLOC/: malloc.c malloc.h
  group SYSTEM
    ./SYSTEM/sys/: sys.c sys.h
    ./SYSTEM/delay/: delay.c delay.h
    ./SYSTEM/usart/: usart.c usart.h
  group LWIP_NETIF
    ./LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group STM32_ETH_DRIVER
    ./STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
    ./STM32F4x7_ETH_Driver/inc/: stm32f4x7_eth.h stm32f4x7_eth_conf.h
  group STM32_CONF
    ./STM32_CONF/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
