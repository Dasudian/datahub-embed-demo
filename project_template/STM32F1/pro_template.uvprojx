# Keil uVision project pro_template.uvprojx, settings and files
target Tem (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pro_template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\DATAHUB_API\inc;.\DATAHUB_API;.\UCOSII\CONFIG;.\UCOSII\CORE;.\UCOSII\PORT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group DATAHUB_LIB
    ./DATAHUB_LIB/: dasudian-datahub-STM32F1-v2.0.0.lib
  group DATAHUB_API
    ./DATAHUB_API/: DataHubClient.h DatahubNetwork.h DatahubTimer.h
  group USER
    ./USER/: DatahubNetwork.c main.c DatahubTimer.c
